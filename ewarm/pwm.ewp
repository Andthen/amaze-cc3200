# IAR project pwm.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; TIMER1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../../driverlib/; ../../../inc/; ../../common; ../../../oslib/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pwm.bin
  ILINK.IlinkOutputFile: pwm.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: filter.c i2cdev.c imu.c kalman.hpp led.c ledseq.c main.c motors.c mpu6050.c pinmux.c README.md sensfusion6.c stabilizer.c system.c
    ../../common/: gpio_if.c i2c_if.c startup_ewarm.c timer_if.c uart_if.c
